# Keil uVision project ucos.uvprojx, settings and files
target Demo (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ucos
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: HSE_VALUE=12000000,DEBUG,VECT_TAB_SRAM
  c include: .\Application\inc;.\uCOS-II\Ports;.\uCOS-II\Source
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\config\STM3210B-EVAL_ram.sct
  group Application
    ./Application/: app_main.c app_hooks.c bsp.c light_ctrl.c debug.c misc_lib.c nor_flash.c
  group ucos-ii
    ./uCOS-II/Source/: ucos_ii.c
  group Port
    ./uCOS-II/Ports/: os_cpu_c.c os_dbg.c os_cpu_a.asm
software components: CMSIS:CORE 3.40.0, Device:DMA 1.01.0, Device:GPIO 1.01.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:CRC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0
